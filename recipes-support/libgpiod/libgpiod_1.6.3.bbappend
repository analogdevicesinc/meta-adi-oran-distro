# Disable libgpiod_1.6.3.bb recipe
COMPATIBLE_MACHINE = "NULL"
