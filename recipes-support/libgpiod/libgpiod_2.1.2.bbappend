# Disable libgpiod_2.1.2.bb recipe
COMPATIBLE_MACHINE = "NULL"
