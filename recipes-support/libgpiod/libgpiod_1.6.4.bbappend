# Disable libgpiod_1.6.4.bb recipe
COMPATIBLE_MACHINE = "NULL"
