PACKAGECONFIG:remove = "gcrypt"