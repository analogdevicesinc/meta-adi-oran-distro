LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING.MIT;md5=3da9cfbcb788c80a0384361b4de20420"

require libuiomem.inc

SRCREV = "e4112c3431d538809fd2bbb5bf58ec1bc2e1a83a"

