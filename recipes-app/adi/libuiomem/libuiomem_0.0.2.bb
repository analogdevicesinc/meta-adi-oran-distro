LICENSE = "CLOSED"
LIC_FILES_CHKSUM = ""

require libuiomem.inc

SRCREV = "ab7798ccfed6b4e3def05f4f4b53ed8ccb0204f2"

