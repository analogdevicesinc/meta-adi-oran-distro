LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING.MIT;md5=3da9cfbcb788c80a0384361b4de20420"

require libuiomem.inc

SRCREV = "d07a315061459225b1f917c34cbd080cbbad9001"

